# Keil uVision project RTThreadNano.uvproj, settings and files
target STC32G RT-Thread Nano (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: RTThreadNano +hex
  link misc: CLASSES (EDATA (0x0-0xFFF), HDATA (0x0-0xFFF), XDATA (0x10000-0x11FFF), HCONST (0xFE2000-0xFFFFFF))
  group Application
    ./app/: main.c gui.c gui_console.c
    ./kernel/src/: mem.c
    ./port/: dynamic_stack.c
  group RT-Thread
    ./kernel/src/: clock.c idle.c ipc.c irq.c kservice.c object.c scheduler.c thread.c timer.c
  group C251 CPU port
    ./port/: cpuport.c context.a51 startup.a51 list.c
  group Board support
    ./bsp/: board.c TFT480x320-V2.c lcd_text.c
  group FinSH MSH
    ./components/finsh/: shell.c msh.c
    ./app/: commands.c
  group USB CDC
    ./bsp/: usb_console.c
    ./bsp/usb/: usb.c usb_desc.c usb_req_std.c usb_req_class.c usb_req_vendor.c util.c
